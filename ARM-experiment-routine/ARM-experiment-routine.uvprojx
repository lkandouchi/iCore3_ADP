# Keil uVision project ARM-experiment-routine.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\include;.\fwlib\inc;.\sys_Test
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group start_up
    ./: startup_stm32f40_41xxx.s
  group main
    ./main/: main.cpp
  group driver
    ./driver/: stm32f4xx_it.c system_stm32f4xx.c
  group fwlib
    ./fwlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
  group Sys_Test
    ./sys_Test/: ledTest.cpp
software components: CMSIS:CORE 4.3.0
